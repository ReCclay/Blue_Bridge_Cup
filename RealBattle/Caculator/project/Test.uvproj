# Keil uVision project Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Test +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceFiles
    ./: STARTUP.A51
    ../source/: main.c lcd1602.c keyboard.c
  group IncludeFIles
    ../source/: config.h lcd1602.h main.h keyboard.h
