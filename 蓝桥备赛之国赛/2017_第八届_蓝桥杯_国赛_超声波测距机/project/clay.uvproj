# Keil uVision project clay.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: clay +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ../source/: main.c ds18b20.c ds1302.c keyboard.c led.c time.c eeprom.c i2c.c pcf8591.c
  group Inc
    ../source/: config.h ds18b20.h ds1302.h keyboard.h led.h time.h eeprom.h i2c.h pcf8591.h main.h
