# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceFiles
    ../source/: main.c led.c time.c i2c.c pcf8591.c keyboard.c
  group IncludeFIles
    ../source/: config.h led.h time.h i2c.h pcf8591.h keyboard.h
