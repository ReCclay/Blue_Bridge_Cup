# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceFiles
    ../source/: ds1302.c keyboard.c led.c main.c e2prom.c i2.c time.c pcf8591.c
  group IncludeFiles
    ../source/: config.h ds1302.h keyboard.h led.h i2c.h e2prom.h time.h pcf8581.h main.h
