# Keil uVision project Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Test +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceFIles
    ../source/: ds18b20.c keyboard.c led.c main.c time.c
  group IncludeFiles
    ../source/: config.h ds18b20.h keyboard.h led.h time.h main.h
