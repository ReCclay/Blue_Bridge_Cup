# Keil uVision project 233.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 233 +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceFIles
    ../source/: main.c keyboard.c digital.c DS1302.c DS18B20.c
  group IncludeFiles
    ../source/: digital.h keyboard.h main.h config.h DS1302.h DS18B20.h
