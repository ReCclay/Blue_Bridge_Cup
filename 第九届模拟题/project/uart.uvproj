# Keil uVision project uart.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: uart +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceFiles
    ../source/: main.c ds1302.c keyboard.c time.c led.c ds18b20.c
  group IncludeFIles
    ../source/: config.h main.h ds1302.h keyboard.h time.h led.h ds18b20.h
