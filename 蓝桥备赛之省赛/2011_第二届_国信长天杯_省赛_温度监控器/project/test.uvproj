# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceFIles
    ../source/: ds18b20.c ds1302.c e2prom.c i2c.c keyboard.c led.c main.c pcf8591.c time.c
  group IncludeFIles
    ../source/: config.h ds18b20.h ds1302.h e2prom.h i2c.h keyboard.h led.h pcf8591.h time.h
