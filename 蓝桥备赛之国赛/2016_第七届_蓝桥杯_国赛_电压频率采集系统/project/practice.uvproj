# Keil uVision project practice.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: practice +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ../source/: led.c main.c keyboard.c ds1302.c time.c ds18b20.c iic.c eeprom.c pcf8591.c
  group Inc
    ../source/: config.h led.h keyboard.h main.h ds1302.h time.h ds18b20.h iic.h eeprom.h pcf8591.h
